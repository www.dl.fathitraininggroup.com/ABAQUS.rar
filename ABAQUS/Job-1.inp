*Heading
** Job name: Job-1 Model name: Model-1
** Generated by: Abaqus/CAE 2023
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=P52P-615w-bifacial
*Node
      1,   4604.91895,   2469.85327,         -47.
      2,   4604.91895,   2469.85327,         -45.
      3,   4601.44482,   2482.58716,         -45.
      4,   4596.94287,   2481.35889,         -45.
      5,   4596.94287,   2481.35889,         -47.
      6,   4595.05713,   2463.01636,         -47.
      7,   4595.05713,   2463.01636,         -45.
      8,        4603.,   2468.52271,         -45.
      9,   4584.06885,   2468.76929,         -47.
     10,   4584.06885,   2468.76929,         -45.
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*Element, type=C3D10
     1,  12342,  54134,  12341,  12412,  57127,  57126,  57125,  57129,  57128,  57130
     2,  39505,  54135,  25393,  39693,  57133,  57132,  57131,  57135,  57134,  57136
     3,  37258,  37069,  37070,  54136,  57139,  57138,  57137,  57141,  57140,  57142
     4,  54137,  16655,  54138,  37068,  57145,  57144,  57143,  57147,  57146,  57148
     5,  54138,  37257,  37256,  17052,  57151,  57150,  57149,  57153,  57152,  57154
     6,  54137,  16656,  54136,  17051,  57157,  57156,  57155,  57159,  57158,  57160
     7,  37200,  54139,  54140,  16795,  57163,  57162,  57161,  57165,  57164,  57166
     8,  54139,  54141,  16797,  37201,  57169,  57168,  57167,  57171,  57170,  57172
     9,  54141,  16911,  16910,  37389,  57175,  57174,  57173,  57177,  57176,  57178
    10,  54139,  54140,  37388,  37200,  57162,  57180,  57179,  57163,  57161,  57181
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*Nset, nset=_PickedSet6, internal, generate
      1,  334922,       1
*Elset, elset=_PickedSet6, internal, generate
      1,  166274,       1
** Section: Section-1
*Solid Section, elset=_PickedSet6, material=St37
,
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=P52P-615w-bifacial-1, part=P52P-615w-bifacial
*End Instance
**
*Node
      1,        6924.,           0.,        2420.
*Node
      2,        6924.,           0., 6.15116846e-11
*Node
      3,        4616.,           0.,        2420.
*Node
      4,        4616.,           0., 4.09912104e-11
*Node
      5,        2308.,           0.,        2420.
*Node
      6,        2308.,           0., 2.04920525e-11
*Node
      7, -6.9388939e-15,           0.,        2420.
*Node
      8, -6.9388939e-15,           0.,           0.
*Node
      9,        3492.,   2077.56494,       1232.5
*Nset, nset=_PickedSet89, internal
 1,
*Nset, nset=_PickedSet91, internal
 2,
*Nset, nset=_PickedSet93, internal
 3,
*Nset, nset=_PickedSet95, internal
 4,
*Nset, nset=_PickedSet97, internal
 5,
*Nset, nset=_PickedSet99, internal
 6,
*Nset, nset=_PickedSet101, internal
 7,
*Nset, nset=_PickedSet103, internal
 8,
*Nset, nset=_PickedSet105, internal
 9,
*Nset, nset=_PickedSet106, internal
 9,
*Nset, nset=_PickedSet107, internal
 9,
*Nset, nset=_PickedSet108, internal, generate
 1,  8,  1
*Nset, nset=_PickedSet109, internal
 9,
*Elset, elset=__PickedSurf88_S3, internal, instance=P52P-615w-bifacial-1
  2432, 15291, 45381, 45384, 70762, 73139, 73942, 73948
*Elset, elset=__PickedSurf88_S4, internal, instance=P52P-615w-bifacial-1
  2436, 45097, 69798, 69973, 71585, 73140, 73145, 74175, 74177, 74843, 74858, 86642
*Elset, elset=__PickedSurf88_S2, internal, instance=P52P-615w-bifacial-1
   9037,  69950,  69954,  70428,  71128,  74191,  86626, 117525
*Elset, elset=__PickedSurf88_S1, internal, instance=P52P-615w-bifacial-1
 69801, 74070, 74860, 74866
*Surface, type=ELEMENT, name=_PickedSurf88, internal
__PickedSurf88_S3, S3
__PickedSurf88_S4, S4
__PickedSurf88_S2, S2
__PickedSurf88_S1, S1
*Elset, elset=__PickedSurf90_S4, internal, instance=P52P-615w-bifacial-1
  11144,  17014, 110679, 113654, 119308, 122282, 122293, 122336, 122699, 122700
*Elset, elset=__PickedSurf90_S2, internal, instance=P52P-615w-bifacial-1
  17025, 109894, 115216, 119336, 119345, 120303, 120306, 121328, 121332, 121750, 122305, 122337
*Elset, elset=__PickedSurf90_S3, internal, instance=P52P-615w-bifacial-1
 110672, 111031, 114656, 116677, 119474, 119491, 122338, 122353, 128928
*Elset, elset=__PickedSurf90_S1, internal, instance=P52P-615w-bifacial-1
 112177, 117515, 122570, 122677, 122678
*Surface, type=ELEMENT, name=_PickedSurf90, internal
__PickedSurf90_S4, S4
__PickedSurf90_S2, S2
__PickedSurf90_S3, S3
__PickedSurf90_S1, S1
*Elset, elset=__PickedSurf92_S1, internal, instance=P52P-615w-bifacial-1
  2797, 75132, 75136, 75256, 78596
*Elset, elset=__PickedSurf92_S4, internal, instance=P52P-615w-bifacial-1
  2801, 75229, 75242, 75244, 78956, 79044
*Elset, elset=__PickedSurf92_S2, internal, instance=P52P-615w-bifacial-1
 14464, 19039, 19149, 46343, 75218, 75220, 76868, 78959, 79041, 79622, 79636, 99063
*Elset, elset=__PickedSurf92_S3, internal, instance=P52P-615w-bifacial-1
  14468,  46561,  76049,  76203,  76507,  78590,  78821,  79038, 116199
*Surface, type=ELEMENT, name=_PickedSurf92, internal
__PickedSurf92_S1, S1
__PickedSurf92_S4, S4
__PickedSurf92_S2, S2
__PickedSurf92_S3, S3
*Elset, elset=__PickedSurf94_S3, internal, instance=P52P-615w-bifacial-1
   4384,  18237,  18238,  43000,  88114,  89274, 115866
*Elset, elset=__PickedSurf94_S2, internal, instance=P52P-615w-bifacial-1
   6321,  38970,  73536,  73561,  82001,  82014,  88098,  89260,  90262,  90275,  90555,  90556, 124070
*Elset, elset=__PickedSurf94_S4, internal, instance=P52P-615w-bifacial-1
 29850, 42991, 73549, 75054, 77657, 82017, 88105, 90317
*Elset, elset=__PickedSurf94_S1, internal, instance=P52P-615w-bifacial-1
 73542, 82028, 89256, 90276, 90283, 90289, 90307, 90423
*Surface, type=ELEMENT, name=_PickedSurf94, internal
__PickedSurf94_S3, S3
__PickedSurf94_S2, S2
__PickedSurf94_S4, S4
__PickedSurf94_S1, S1
*Elset, elset=__PickedSurf96_S1, internal, instance=P52P-615w-bifacial-1
  2222, 18325, 79772, 79773, 84935
*Elset, elset=__PickedSurf96_S4, internal, instance=P52P-615w-bifacial-1
  17416,  48283,  79828,  79833,  79852,  81383,  82123,  83106,  84258,  84261,  84921, 128944
*Elset, elset=__PickedSurf96_S2, internal, instance=P52P-615w-bifacial-1
 18328, 47930, 64691, 80438, 83902, 84122, 84141, 84266, 84269, 86731, 91739
*Elset, elset=__PickedSurf96_S3, internal, instance=P52P-615w-bifacial-1
 47931, 48297, 81965, 83630
*Surface, type=ELEMENT, name=_PickedSurf96, internal
__PickedSurf96_S1, S1
__PickedSurf96_S4, S4
__PickedSurf96_S2, S2
__PickedSurf96_S3, S3
*Elset, elset=__PickedSurf98_S3, internal, instance=P52P-615w-bifacial-1
   1712,  18197,  18198,  67666,  67669,  93554,  97209, 100169
*Elset, elset=__PickedSurf98_S4, internal, instance=P52P-615w-bifacial-1
   1713,  18191,  96203, 103848, 104953, 105879, 105921, 105937, 106169, 131785
*Elset, elset=__PickedSurf98_S2, internal, instance=P52P-615w-bifacial-1
   5885,  67625,  93197,  94463, 100171, 100189, 100199, 104959, 104965, 105910, 106182
*Elset, elset=__PickedSurf98_S1, internal, instance=P52P-615w-bifacial-1
  21437,  92894, 100146, 103838, 105326, 105901, 106066
*Surface, type=ELEMENT, name=_PickedSurf98, internal
__PickedSurf98_S3, S3
__PickedSurf98_S4, S4
__PickedSurf98_S2, S2
__PickedSurf98_S1, S1
*Elset, elset=__PickedSurf100_S1, internal, instance=P52P-615w-bifacial-1
  5436, 85164, 85265, 85810, 88310, 89168
*Elset, elset=__PickedSurf100_S4, internal, instance=P52P-615w-bifacial-1
   5439,  49486,  49494,  85258,  85263,  86068,  90169, 130015, 153015
*Elset, elset=__PickedSurf100_S2, internal, instance=P52P-615w-bifacial-1
 49479, 49481, 69049, 85238, 86597, 87057, 87061, 88155, 88298, 88521, 88866, 89326, 89339, 90175, 90176
*Elset, elset=__PickedSurf100_S3, internal, instance=P52P-615w-bifacial-1
  88518, 130485
*Surface, type=ELEMENT, name=_PickedSurf100, internal
__PickedSurf100_S1, S1
__PickedSurf100_S4, S4
__PickedSurf100_S2, S2
__PickedSurf100_S3, S3
*Elset, elset=__PickedSurf102_S2, internal, instance=P52P-615w-bifacial-1
  17318, 129288, 130386, 131996, 136749, 146418, 146982, 157596
*Elset, elset=__PickedSurf102_S4, internal, instance=P52P-615w-bifacial-1
  21655, 130014, 131477, 138598, 144771, 146992, 147008, 147009, 147020
*Elset, elset=__PickedSurf102_S3, internal, instance=P52P-615w-bifacial-1
  85736, 112109, 134097, 134987, 135957, 138591, 138637, 146972, 147371, 147372
*Elset, elset=__PickedSurf102_S1, internal, instance=P52P-615w-bifacial-1
 131476, 133695, 134635, 134636, 135953, 136771, 138634, 145898, 147251
*Surface, type=ELEMENT, name=_PickedSurf102, internal
__PickedSurf102_S2, S2
__PickedSurf102_S4, S4
__PickedSurf102_S3, S3
__PickedSurf102_S1, S1
*Elset, elset=__PickedSurf104_S2, internal, instance=P52P-615w-bifacial-1
   1076,   5637,   7646,  10051,  10887,  12594,  13704,  13711,  17994,  18571,  24253,  50775,  62940,  97496, 106619, 115420
 115532, 116049, 116395, 129195, 134365, 137080, 144466, 149508
*Elset, elset=__PickedSurf104_S3, internal, instance=P52P-615w-bifacial-1
    702,    738,    740,    794,    913,   1045,   1156,   1180,   1389,   1566,   1593,   1781,   1873,   1921,   2017,   2039
   2415,   2529,   2568,   2594,   2621,   2680,   2729,   2735,   3004,   3165,   3171,   3354,   3444,   3678,   3803,   3840
   3980,   4009,   4015,   4121,   4177,   4312,   4405,   4561,   4781,   4794,   4832,   4918,   5102,   5447,   5531,   5657
   5681,   5788,   5833,   5950,   5957,   6024,   6035,   6096,   6110,   6119,   6128,   6160,   6173,   6183,   6216,   6222
   6262,   6268,   6279,   6280,   6286,   6299,   6349,   6405,   6436,   6442,   6451,   6578,   6591,   6611,   6639,   6661
   6713,   6721,   6764,   6783,   6797,   6809,   6817,   6819,   6826,   6852,   6858,   6871,   6879,   6888,   6931,   6960
   6976,   6993,   7008,   7040,   7048,   7054,   7086,   7107,   7113,   7167,   7179,   7202,   7226,   7246,   7266,   7302
   7327,   7333,   7336,   7360,   7411,   7437,   7483,   7484,   7492,   7493,   7498,   7509,   7510,   7511,   7537,   7546
   7559,   7560,   7576,   7590,   7594,   7606,   7708,   7725,   7881,   8020,   8032,   8043,   8062,   8068,   8103,   8248
   8387,   8416,   8452,   8460,   8524,   8600,   8620,   8638,   8670,   8694,   8713,   8725,   8751,   8864,   8884,   8894
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*Elset, elset=__PickedSurf104_S4, internal, instance=P52P-615w-bifacial-1
   1567,  18016,  18934,  62447,  91899, 106614, 107686, 115521, 115870, 117141, 117282, 118334, 124921, 134341
*Elset, elset=__PickedSurf104_S1, internal, instance=P52P-615w-bifacial-1
  14438,  17663,  88655,  96069, 145701, 159266
*Surface, type=ELEMENT, name=_PickedSurf104, internal
__PickedSurf104_S2, S2
__PickedSurf104_S3, S3
__PickedSurf104_S4, S4
__PickedSurf104_S1, S1
** Constraint: Constraint-1
*Coupling, constraint name=Constraint-1, ref node=_PickedSet89, surface=_PickedSurf88
*Kinematic
** Constraint: Constraint-2
*Coupling, constraint name=Constraint-2, ref node=_PickedSet91, surface=_PickedSurf90
*Kinematic
** Constraint: Constraint-3
*Coupling, constraint name=Constraint-3, ref node=_PickedSet93, surface=_PickedSurf92
*Kinematic
** Constraint: Constraint-4
*Coupling, constraint name=Constraint-4, ref node=_PickedSet95, surface=_PickedSurf94
*Kinematic
** Constraint: Constraint-5
*Coupling, constraint name=Constraint-5, ref node=_PickedSet97, surface=_PickedSurf96
*Kinematic
** Constraint: Constraint-6
*Coupling, constraint name=Constraint-6, ref node=_PickedSet99, surface=_PickedSurf98
*Kinematic
** Constraint: Constraint-7
*Coupling, constraint name=Constraint-7, ref node=_PickedSet101, surface=_PickedSurf100
*Kinematic
** Constraint: Constraint-8
*Coupling, constraint name=Constraint-8, ref node=_PickedSet103, surface=_PickedSurf102
*Kinematic
** Constraint: Constraint-9
*Coupling, constraint name=Constraint-9, ref node=_PickedSet105, surface=_PickedSurf104
*Kinematic
*End Assembly
**
** MATERIALS
**
*Material, name=St37
*Density
 7.85e-09,
*Elastic
200000., 0.3
**
** BOUNDARY CONDITIONS
**
** Name: BC-1 Type: Symmetry/Antisymmetry/Encastre
*Boundary
_PickedSet108, ENCASTRE
** ----------------------------------------------------------------
**
** STEP: Step-1
**
*Step, name=Step-1, nlgeom=NO
*Static
1., 1., 1e-05, 1.
**
** LOADS
**
** Name: Gravity   Type: Gravity
*Dload
, GRAV, 9810., 0., -1., 0.
** Name: Panel Weight   Type: Concentrated force
*Cload
_PickedSet109, 2, -3560.
** Name: Snow Weight   Type: Concentrated force
*Cload
_PickedSet106, 2, -29419.
** Name: Wind   Type: Concentrated force
*Cload
_PickedSet107, 3, 54571.
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=0
**
** FIELD OUTPUT: F-Output-1
**
*Output, field
*Node Output
CF, RF, U
*Element Output, directions=YES
S,
**
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
